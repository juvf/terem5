# IAR project terem4.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401xC ST STM32F401xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F401xx; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: freertos; ; Libraries\STM32F4xx_StdPeriph_Driver\inc; Libraries\Usb\inc; Libraries\Usb; Libraries\CMSIS\Device\ST\STM32F4xx\Include; $TOOLKIT_DIR$\CMSIS\Include\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: terem4.hex
  ILINK.IlinkOutputFile: terem4.out
  ILINK.IlinkIcfFile: terem.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: 5.srec
  ILINK.IlinkOutputFile: cpp.out
  group (top)
    ./: main.cpp main.h osConfig.c osConfig.h
  group freertos
    freertos/: FreeRTOSConfig.h heap_1.c list.c list.h port.c portasm.s queue.c queue.h semphr.h task.h tasks.c timers.c timers.h
  group Libraries
    ./: stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
  group Libraries/CMSIS
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f401xx.s
    Libraries/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Libraries/STM32F4xx_StdPeriph_Driver
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_usart.c
    Libraries/STM32F4xx_StdPeriph_Driver/inc/: misc.h stm32f4xx_gpio.h stm32f4xx_i2c.h stm32f4xx_rcc.h stm32f4xx_usart.h
  group tasks
    tasks/: Checksum.cpp Checksum.h commandsRfd.cpp commandsRfd.h mainTask.cpp mainTask.h taskUartRfd.cpp taskUartRfd.h usbTask.cpp usbTask.h
  group USB
    Libraries/Usb/: usb_bsp.c usb_bsp.h usb_conf.h usb_core.c usb_core.h usb_dcd.c usb_dcd.h usb_dcd_int.c usb_dcd_int.h usb_defines.h usb_regs.h usbd_cdc_core.c usbd_cdc_core.h usbd_cdc_vcp.c usbd_cdc_vcp.h usbd_conf.h usbd_core.c usbd_core.h usbd_def.h usbd_desc.c usbd_desc.h usbd_ioreq.c usbd_ioreq.h usbd_req.c usbd_req.h usbd_usr.c usbd_usr.h
