<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>freertos</name>
    <file>
      <name>$PROJ_DIR$\freertos\event_groups.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\freertos\event_groups.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\freertos\FreeRTOSConfig.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\freertos\heap_1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\freertos\list.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\freertos\list.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\freertos\port.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\freertos\portasm.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\freertos\queue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\freertos\queue.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\freertos\semphr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\freertos\task.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\freertos\tasks.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\freertos\timers.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\freertos\timers.h</name>
    </file>
  </group>
  <group>
    <name>Libraries</name>
    <group>
      <name>CMSIS</name>
      <file>
        <name>$PROJ_DIR$\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates\iar\startup_stm32f401xx.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\CMSIS\Device\ST\STM32F4xx\Include\stm32f4xx.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates\system_stm32f4xx.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\CMSIS\Device\ST\STM32F4xx\Include\system_stm32f4xx.h</name>
      </file>
    </group>
    <group>
      <name>STM32F4xx_StdPeriph_Driver</name>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F4xx_StdPeriph_Driver\src\misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F4xx_StdPeriph_Driver\inc\misc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F4xx_StdPeriph_Driver\inc\stm32f4xx_gpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F4xx_StdPeriph_Driver\inc\stm32f4xx_i2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F4xx_StdPeriph_Driver\inc\stm32f4xx_rcc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_usart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F4xx_StdPeriph_Driver\inc\stm32f4xx_usart.h</name>
      </file>
    </group>
    <group>
      <name>Usb</name>
    </group>
    <file>
      <name>$PROJ_DIR$\stm32f4xx_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm32f4xx_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm32f4xx_it.h</name>
    </file>
  </group>
  <group>
    <name>tasks</name>
    <group>
      <name>sensors</name>
      <file>
        <name>$PROJ_DIR$\tasks\sensor\Sensor.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\tasks\sensor\Sensor.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\tasks\sensor\SensorM10.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\tasks\sensor\SensorM10.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\tasks\Checksum.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\tasks\Checksum.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\tasks\clock.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\tasks\clock.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\tasks\commandsRfd.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\tasks\commandsRfd.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\tasks\configTerem.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\tasks\configTerem.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\tasks\mainTask.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\tasks\mainTask.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\tasks\Process.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\tasks\Process.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\tasks\taskMeasurement.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\tasks\taskMeasurement.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\tasks\taskUartRfd.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\tasks\taskUartRfd.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\tasks\usbTask.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\tasks\usbTask.h</name>
    </file>
  </group>
  <group>
    <name>USB</name>
    <file>
      <name>$PROJ_DIR$\Libraries\Usb\usb_bsp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Usb\usb_bsp.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Usb\usb_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Usb\usb_core.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Usb\usb_core.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Usb\usb_dcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Usb\usb_dcd.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Usb\usb_dcd_int.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Usb\usb_dcd_int.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Usb\usb_defines.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Usb\usb_regs.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Usb\usbd_cdc_core.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Usb\usbd_cdc_core.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Usb\usbd_cdc_vcp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Usb\usbd_cdc_vcp.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Usb\usbd_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Usb\usbd_core.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Usb\usbd_core.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Usb\usbd_def.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Usb\usbd_desc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Usb\usbd_desc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Usb\usbd_ioreq.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Usb\usbd_ioreq.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Usb\usbd_req.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Usb\usbd_req.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Usb\usbd_usr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Usb\usbd_usr.h</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\adc.cpp</name>
  </file>
  <file>
    <name>$PROJ_DIR$\adc.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\flashMx25.cpp</name>
  </file>
  <file>
    <name>$PROJ_DIR$\flashMx25.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\i2c.cpp</name>
  </file>
  <file>
    <name>$PROJ_DIR$\i2c.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\main.cpp</name>
  </file>
  <file>
    <name>$PROJ_DIR$\main.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\osConfig.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\osConfig.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\structCommon.h</name>
  </file>
</project>


